# Repository picorubykaigi/adventure-board-pcb

File README.md:

# adventure-board-pcb

PicoRubyKaigi 向け RP2350 ボード「adventure-board」の基板設計データです（KiCad 9）。

現在のリビジョン: **V1**（量産版）

## 基板仕様

| 項目 | 値 |
|---|---|
| 外形 | 130 × 90 mm |
| 層数 | 4 層 |
| 板厚 | 1.6 mm |
| 表面処理 | HASL |

## ファイル構成

```
adventure-board.kicad_pro / .kicad_sch / .kicad_pcb   KiCad プロジェクト
fp-lib-table, sym-lib-table                          プロジェクトローカルライブラリ定義
lib/, libs/                                          シンボル・フットプリント（3D モデルは含みません）
docs/adventure-board-schematic.pdf                   回路図 PDF
production/v1/                                       V1（量産版）の製造データ
  adventure-board.zip    ガーバー + ドリル
  bom.csv                BOM（JLCPCB 形式, LCSC 部品番号付き）
  positions.csv          部品配置データ（CPL）
  designators.csv        リファレンス一覧
  netlist.ipc            IPC-D-356 ネットリスト
  adventure-board-schematic.pdf  回路図 PDF
production/pv1/                                      PV1（量産試作）発注時の製造データ（参考）
```

製造データは KiCad の [Fabrication Toolkit](https://github.com/bennymeg/Fabrication-Toolkit) プラグインで出力したものです。

## リビジョン履歴

| リビジョン | 内容 |
|---|---|
| V1 | 量産版。下側 2 つの取付穴を上側と同じく角から 4.5 mm の位置に変更、シルクの「PV1」表記を削除 |
| PV1 | 量産試作 |

## 3D モデルについて

3D モデル（STEP/WRL）は同梱していません。基板エディタの 3D ビューアで一部部品が表示されませんが、ERC/DRC や製造データの出力には影響しません。

## 第三者由来のデータ

- `libs/RP2350_60QFN_minimal.pretty`: Raspberry Pi RP2350A Minimal Board（RP-006440-DD-2）の設計データ由来のフットプリント
- `lib/easyeda2kicad`, `libs/PicoBoard.*`: LCSC/EasyEDA の部品ライブラリを easyeda2kicad で変換し、必要に応じて修正したもの

## ライセンス

Copyright PicoRubyKaigi 2026.

This source describes Open Hardware and is licensed under the CERN-OHL-P v2.
You may redistribute and modify this documentation and make products using it
under the terms of the CERN-OHL-P v2 (https://cern.ch/cern-ohl).
This documentation is distributed WITHOUT ANY EXPRESS OR IMPLIED WARRANTY,
INCLUDING OF MERCHANTABILITY, SATISFACTORY QUALITY AND FITNESS FOR A
PARTICULAR PURPOSE. Please see the CERN-OHL-P v2 for applicable conditions.

全文は [LICENSE](LICENSE) を参照してください。

## KiCad design adventure-board.kicad_pcb

Schematic: adventure-board.kicad_sch

Parts:
C1, C3, C26, C31, C32, C35, C36: 10uF; C_0805_2012Metric; LCSC Part C1713
C2, C9, C10, C11, C12, C13, C14, C15, C16, C18, C19, C23, C24, C28, C29, C30, C37, C38: 100nF; C_0402_1005Metric; LCSC Part C1525
C4: 22uF; C_0805_2012Metric; LCSC Part C45783
C5, C6, C7, C8: 4.7uF; C_0402_1005Metric; LCSC Part C23733
C20, C21: 15pF; C_0402_1005Metric; LCSC Part C1548
C22, C25: 3.3nF; C_0402_1005Metric; LCSC Part C3881585
C27, C33, C34: 1uF; C_0402_1005Metric; LCSC Part C52923
D2: LED RED; LED_0603_1608Metric; LCSC Part C2286
D3: LED GREEN; LED_0805_2012Metric; LCSC Part C2297
J1: BreadboardHdr_2x10; PinSocket_2x10_P2.54mm_Vertical; LCSC Part C2897411
J2: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical; not fitted
J4, J5: HY2.0-4P-WT; CONN-SMD_HY2.0-4P; LCSC Part C722729
L1: 3.3uH; IND-SMD_L2.0-W1.6_AOTA-B201610S3R3-101-T; LCSC Part C42411119
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16, LED17, LED18, LED19, LED20, LED21, LED22, LED23, LED24, LED25, LED26, LED27, LED28, LED29, LED30, LED31, LED32, LED33, LED34, LED35, LED36, LED37, LED38, LED39, LED40, LED41, LED42, LED43, LED44, LED45, LED46, LED47, LED48, LED49, LED50, LED51, LED52, LED53, LED54, LED55, LED56, LED57, LED58, LED59, LED60, LED61, LED62, LED63, LED64, LED65, LED66, LED67, LED68, LED69, LED70, LED71, LED72, LED73, LED74, LED75, LED76, LED77, LED78, LED79, LED80, LED81, LED82, LED83, LED84, LED85, LED86, LED87, LED88, LED89, LED90, LED91, LED92, LED93, LED94, LED95, LED96, LED97, LED98, LED99, LED100, LED101, LED102, LED103, LED104, LED105, LED106, LED107, LED108, LED109, LED110, LED111, LED112, LED113, LED114, LED115, LED116, LED117, LED118, LED119, LED120, LED121, LED122, LED123, LED124, LED125, LED126, LED127, LED128, LED129, LED130, LED131, LED132, LED133, LED134, LED135, LED136, LED137, LED138, LED139, LED140, LED141, LED142, LED143, LED144, LED145, LED146, LED147, LED148, LED149, LED150, LED151, LED152, LED153, LED154, LED155, LED156, LED157, LED158, LED159, LED160, LED161, LED162, LED163, LED164, LED165, LED166, LED167, LED168, LED169, LED170, LED171, LED172, LED173, LED174, LED175, LED176, LED177, LED178, LED179, LED180, LED181, LED182, LED183, LED184, LED185, LED186, LED187, LED188, LED189, LED190, LED191, LED192, LED193, LED194, LED195, LED196, LED197, LED198, LED199, LED200, LED201, LED202, LED203, LED204, LED205, LED206, LED207, LED208, LED209, LED210, LED211, LED212, LED213, LED214, LED215, LED216, LED217, LED218, LED219, LED220, LED221, LED222, LED223, LED224, LED225, LED226, LED227, LED228, LED229, LED230, LED231, LED232, LED233, LED234, LED235, LED236, LED237, LED238, LED239, LED240, LED241, LED242, LED243, LED244, LED245, LED246, LED247, LED248, LED249, LED250, LED251, LED252, LED253, LED254, LED255, LED256: LED_W; LED_0402_Compact_P1.6mm; LCSC Part C20613596
LS1: SPK_8R_0.7W; BUZ-SMD_4P-L13.0-W13.0-P11.4-BL; LCSC Part C18186315
R1, R2: 5.1k; R_0402_1005Metric; LCSC Part C25905
R3, R4: 27; R_0402_1005Metric; LCSC Part C25100
R5: 33; R_0402_1005Metric; LCSC Part C25105
R6, R9: 47k; R_0402_1005Metric; LCSC Part C25792
R7, R8, R10, R14, R43: 1k; R_0402_1005Metric; LCSC Part C11702
R11, R12: 2.2k; R_0402_1005Metric; LCSC Part C25879
R13, R15, R29, R30: 4.7k; R_0402_1005Metric; LCSC Part C25900
R16, R26: 0; R_0603_1608Metric; LCSC Part C21189; not fitted
R17, R18: 33k; R_0402_1005Metric; LCSC Part C25779
R19, R24, R33, R34, R35, R36, R37, R38: 10k; R_0402_1005Metric; LCSC Part C25744
R20, R21, R22, R23: 22; R_0402_1005Metric; LCSC Part C25092
R25, R27, R28, R48, R49: 0; R_0603_1608Metric; LCSC Part C21189
R31, R32: 2k; R_0402_1005Metric; LCSC Part C4109
SW1, SW2, SW3, SW4, SW5, SW6: SW_MEC_5G; KEY-SMD_4P-L6.0-W6.0-P4.50-LS8.6; LCSC Part C381038
SW7: BOOTSEL; SW-SMD_L3.9-W3.0-P4.45; LCSC Part C720477
SW8: RESET; SW-SMD_L3.9-W3.0-P4.45; LCSC Part C720477
U1: RP2350A; RP2350-QFN-60-1EP_7x7_P0.4mm_EP3.4x3.4mm_ThermalVias; LCSC Part C42411118
U2: H5VHD3BC; SOD-323_L1.8-W1.3-LS2.7-BI; MPN H5VHD3BC; LCSC Part C20615804
U3: GT-USB-7010ASV; USB-C-SMD_G-SWITCH_GT-USB-7010ASV; MPN GT-USB-7010ASV; LCSC Part C2988369
U4: W25Q64JVSSIQ; SOIC-8_L5.3-W5.3-P1.27-LS8.0-BL; MPN W25Q64JVSSIQ; LCSC Part C179171
U6: PESD5V0U2BT; SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR; MPN PESD5V0U2BT; LCSC Part C2905622
U7: TPS2065CDBV; SOT-23-5; LCSC Part C353882
U8: PAM8302AASCR; MSOP-8_L3.0-W3.0-P0.65-LS5.0-BL; LCSC Part C113367
U9: AMS1117-3.3; SOT-223-3_L6.5-W3.4-P2.30-LS7.0-BR; LCSC Part C6186
U10, U11: IS31FL3729; QFN-32_L4.0-W4.0-P0.40-TL-EP2.8; LCSC Part C2940549
Y1: 12MHz; CRYSTAL-SMD_4P-L3.2-W2.5-BL; LCSC Part C20625731

Connections:
1V1: C5.1, C6.1, C18.1, C19.1, L1.2, U1.6 (DVDD), U1.23 (DVDD), U1.39 (DVDD), U1.50 (VREG_FB)
3V3: C4.1, C7.2, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C28.1, C36.2, J1.4, R5.1, R11.2, R12.2, R19.1, R25.1, R26.1, R28.1, R29.1, R30.1, R32.2, R33.1, R34.1, R35.1, R36.1, R37.1, R38.1, U1.1 (IOVDD), U1.11 (IOVDD), U1.20 (IOVDD), U1.30 (IOVDD), U1.38 (IOVDD), U1.45 (IOVDD), U1.49 (VREG_VIN), U1.53 (USB_OTP_VDD), U1.54 (QSPI_IOVDD), U4.8 (VCC), U9.2 (VOUT), U9.4 (VOUT)
5V: C3.1, C26.1, C27.1, C29.1, C30.1, C31.1, C32.1, C35.2, J1.1, R16.1, R27.1, U7.1 (OUT), U8.6 (VDD), U9.3 (VIN), U10.23 (VCC), U11.23 (VCC)
ADC_AVDD: C9.1, R28.2, U1.44 (ADC_AVDD)
CC1: R1.1, U3.A5 (CC1)
CC2: R2.1, U3.B5 (CC2)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.1, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.1, C36.1, C37.2, C38.2, D2.1 (K), D3.1 (K), J1.2, J1.3, J1.18, J1.19, J1.20, J2.1, J4.1, J4.5, J4.6, J5.1, J5.5, J5.6, LS1.3 (DUMMY), LS1.4 (DUMMY), R1.2, R2.2, R13.1, R15.2, R17.2, R18.2, R43.1, SW1.3 (B), SW1.4 (B), SW2.3 (B), SW2.4 (B), SW3.3 (B), SW3.4 (B), SW4.3 (B), SW4.4 (B), SW5.3 (B), SW5.4 (B), SW6.3 (B), SW6.4 (B), SW7.2, U1.47 (VREG_PGND), U1.61 (GND), U2.1, U3.1 (SHELL), U3.2 (SHELL), U3.3 (SHELL), U3.4 (SHELL), U3.A1B12 (GND), U3.B1A12 (GND), U4.4 (GND), U6.3, U7.2 (GND), U8.7 (GND), U9.1 (GND), U10.9 (GND), U10.24 (GND), U10.28 (AD), U10.33 (EP), U11.9 (GND), U11.24 (GND), U11.33 (EP), Y1.2 (GND), Y1.4 (GND)
GPIO2: J1.5, U1.4 (GPIO2)
GPIO3: J1.6, U1.5 (GPIO3)
GPIO8: J1.7, U1.12 (GPIO8)
GPIO9: J1.8, U1.13 (GPIO9)
GPIO10: R14.1, U1.14 (GPIO10)
GPIO11: J1.9, U1.15 (GPIO11)
GPIO12: J1.10, U1.16 (GPIO12)
GPIO13: J1.11, U1.17 (GPIO13)
GPIO14: J1.12, U1.18 (GPIO14)
GPIO15: J1.13, U1.19 (GPIO15)
GPIO16: J1.14, R31.2, U1.27 (GPIO16)
GPIO17: R33.2, SW1.1 (A), SW1.2 (A), U1.28 (GPIO17)
GPIO18: R34.2, SW2.1 (A), SW2.2 (A), U1.29 (GPIO18)
GPIO19: R35.2, SW3.1 (A), SW3.2 (A), U1.31 (GPIO19)
GPIO20: R36.2, SW4.1 (A), SW4.2 (A), U1.32 (GPIO20)
GPIO21: R37.2, SW5.1 (A), SW5.2 (A), U1.33 (GPIO21)
GPIO22: R38.2, SW6.1 (A), SW6.2 (A), U1.34 (GPIO22)
GPIO23: R15.1, U1.35 (GPIO23), U8.1 (~SD)
GPIO24: C37.1, C38.1, R13.2, U1.36 (GPIO24), U10.29 (SDB), U11.29 (SDB)
GPIO25: J1.15, U1.37 (GPIO25)
GPIO26: J1.16, U1.40 (GPIO26/ADC0)
GPIO27: J1.17, U1.41 (GPIO27/ADC1)
GPIO28: J5.3, U1.42 (GPIO28/ADC2)
GPIO29: J5.4, U1.43 (GPIO29/ADC3)
I2C1_SCL: J4.4, R29.2, U1.10 (GPIO7)
I2C1_SDA: J4.3, R30.2, U1.9 (GPIO6)
MTX_CA1: LED1.1 (K), LED17.1 (K), LED33.1 (K), LED49.1 (K), LED65.1 (K), LED81.1 (K), LED97.1 (K), LED113.1 (K), U10.30 (CS1)
MTX_CA2: LED2.1 (K), LED18.1 (K), LED34.1 (K), LED50.1 (K), LED66.1 (K), LED82.1 (K), LED98.1 (K), LED114.1 (K), U10.31 (CS2)
MTX_CA3: LED3.1 (K), LED19.1 (K), LED35.1 (K), LED51.1 (K), LED67.1 (K), LED83.1 (K), LED99.1 (K), LED115.1 (K), U10.32 (CS3)
MTX_CA4: LED4.1 (K), LED20.1 (K), LED36.1 (K), LED52.1 (K), LED68.1 (K), LED84.1 (K), LED100.1 (K), LED116.1 (K), U10.1 (CS4)
MTX_CA5: LED5.1 (K), LED21.1 (K), LED37.1 (K), LED53.1 (K), LED69.1 (K), LED85.1 (K), LED101.1 (K), LED117.1 (K), U10.2 (CS5)
MTX_CA6: LED6.1 (K), LED22.1 (K), LED38.1 (K), LED54.1 (K), LED70.1 (K), LED86.1 (K), LED102.1 (K), LED118.1 (K), U10.3 (CS6)
MTX_CA7: LED7.1 (K), LED23.1 (K), LED39.1 (K), LED55.1 (K), LED71.1 (K), LED87.1 (K), LED103.1 (K), LED119.1 (K), U10.4 (CS7)
MTX_CA8: LED8.1 (K), LED24.1 (K), LED40.1 (K), LED56.1 (K), LED72.1 (K), LED88.1 (K), LED104.1 (K), LED120.1 (K), U10.5 (CS8)
MTX_CA9: LED9.1 (K), LED25.1 (K), LED41.1 (K), LED57.1 (K), LED73.1 (K), LED89.1 (K), LED105.1 (K), LED121.1 (K), U10.6 (CS9)
MTX_CA10: LED10.1 (K), LED26.1 (K), LED42.1 (K), LED58.1 (K), LED74.1 (K), LED90.1 (K), LED106.1 (K), LED122.1 (K), U10.7 (CS10)
MTX_CA11: LED11.1 (K), LED27.1 (K), LED43.1 (K), LED59.1 (K), LED75.1 (K), LED91.1 (K), LED107.1 (K), LED123.1 (K), U10.8 (CS11)
MTX_CA12: LED12.1 (K), LED28.1 (K), LED44.1 (K), LED60.1 (K), LED76.1 (K), LED92.1 (K), LED108.1 (K), LED124.1 (K), U10.10 (CS12)
MTX_CA13: LED13.1 (K), LED29.1 (K), LED45.1 (K), LED61.1 (K), LED77.1 (K), LED93.1 (K), LED109.1 (K), LED125.1 (K), U10.11 (CS13)
MTX_CA14: LED14.1 (K), LED30.1 (K), LED46.1 (K), LED62.1 (K), LED78.1 (K), LED94.1 (K), LED110.1 (K), LED126.1 (K), U10.12 (CS14)
MTX_CA15: LED15.1 (K), LED31.1 (K), LED47.1 (K), LED63.1 (K), LED79.1 (K), LED95.1 (K), LED111.1 (K), LED127.1 (K), U10.13 (CS15)
MTX_CA16: LED16.1 (K), LED32.1 (K), LED48.1 (K), LED64.1 (K), LED80.1 (K), LED96.1 (K), LED112.1 (K), LED128.1 (K), U10.14 (SW9/CS16)
MTX_CB1: LED129.1 (K), LED145.1 (K), LED161.1 (K), LED177.1 (K), LED193.1 (K), LED209.1 (K), LED225.1 (K), LED241.1 (K), U11.14 (SW9/CS16)
MTX_CB2: LED130.1 (K), LED146.1 (K), LED162.1 (K), LED178.1 (K), LED194.1 (K), LED210.1 (K), LED226.1 (K), LED242.1 (K), U11.13 (CS15)
MTX_CB3: LED131.1 (K), LED147.1 (K), LED163.1 (K), LED179.1 (K), LED195.1 (K), LED211.1 (K), LED227.1 (K), LED243.1 (K), U11.12 (CS14)
MTX_CB4: LED132.1 (K), LED148.1 (K), LED164.1 (K), LED180.1 (K), LED196.1 (K), LED212.1 (K), LED228.1 (K), LED244.1 (K), U11.11 (CS13)
MTX_CB5: LED133.1 (K), LED149.1 (K), LED165.1 (K), LED181.1 (K), LED197.1 (K), LED213.1 (K), LED229.1 (K), LED245.1 (K), U11.10 (CS12)
MTX_CB6: LED134.1 (K), LED150.1 (K), LED166.1 (K), LED182.1 (K), LED198.1 (K), LED214.1 (K), LED230.1 (K), LED246.1 (K), U11.8 (CS11)
MTX_CB7: LED135.1 (K), LED151.1 (K), LED167.1 (K), LED183.1 (K), LED199.1 (K), LED215.1 (K), LED231.1 (K), LED247.1 (K), U11.7 (CS10)
MTX_CB8: LED136.1 (K), LED152.1 (K), LED168.1 (K), LED184.1 (K), LED200.1 (K), LED216.1 (K), LED232.1 (K), LED248.1 (K), U11.6 (CS9)
MTX_CB9: LED137.1 (K), LED153.1 (K), LED169.1 (K), LED185.1 (K), LED201.1 (K), LED217.1 (K), LED233.1 (K), LED249.1 (K), U11.5 (CS8)
MTX_CB10: LED138.1 (K), LED154.1 (K), LED170.1 (K), LED186.1 (K), LED202.1 (K), LED218.1 (K), LED234.1 (K), LED250.1 (K), U11.4 (CS7)
MTX_CB11: LED139.1 (K), LED155.1 (K), LED171.1 (K), LED187.1 (K), LED203.1 (K), LED219.1 (K), LED235.1 (K), LED251.1 (K), U11.3 (CS6)
MTX_CB12: LED140.1 (K), LED156.1 (K), LED172.1 (K), LED188.1 (K), LED204.1 (K), LED220.1 (K), LED236.1 (K), LED252.1 (K), U11.2 (CS5)
MTX_CB13: LED141.1 (K), LED157.1 (K), LED173.1 (K), LED189.1 (K), LED205.1 (K), LED221.1 (K), LED237.1 (K), LED253.1 (K), U11.1 (CS4)
MTX_CB14: LED142.1 (K), LED158.1 (K), LED174.1 (K), LED190.1 (K), LED206.1 (K), LED222.1 (K), LED238.1 (K), LED254.1 (K), U11.32 (CS3)
MTX_CB15: LED143.1 (K), LED159.1 (K), LED175.1 (K), LED191.1 (K), LED207.1 (K), LED223.1 (K), LED239.1 (K), LED255.1 (K), U11.31 (CS2)
MTX_CB16: LED144.1 (K), LED160.1 (K), LED176.1 (K), LED192.1 (K), LED208.1 (K), LED224.1 (K), LED240.1 (K), LED256.1 (K), U11.30 (CS1)
MTX_R1: LED1.2 (A), LED2.2 (A), LED3.2 (A), LED4.2 (A), LED5.2 (A), LED6.2 (A), LED7.2 (A), LED8.2 (A), LED9.2 (A), LED10.2 (A), LED11.2 (A), LED12.2 (A), LED13.2 (A), LED14.2 (A), LED15.2 (A), LED16.2 (A), U10.22 (SW1)
MTX_R2: LED17.2 (A), LED18.2 (A), LED19.2 (A), LED20.2 (A), LED21.2 (A), LED22.2 (A), LED23.2 (A), LED24.2 (A), LED25.2 (A), LED26.2 (A), LED27.2 (A), LED28.2 (A), LED29.2 (A), LED30.2 (A), LED31.2 (A), LED32.2 (A), U10.21 (SW2)
MTX_R3: LED33.2 (A), LED34.2 (A), LED35.2 (A), LED36.2 (A), LED37.2 (A), LED38.2 (A), LED39.2 (A), LED40.2 (A), LED41.2 (A), LED42.2 (A), LED43.2 (A), LED44.2 (A), LED45.2 (A), LED46.2 (A), LED47.2 (A), LED48.2 (A), U10.20 (SW3)
MTX_R4: LED49.2 (A), LED50.2 (A), LED51.2 (A), LED52.2 (A), LED53.2 (A), LED54.2 (A), LED55.2 (A), LED56.2 (A), LED57.2 (A), LED58.2 (A), LED59.2 (A), LED60.2 (A), LED61.2 (A), LED62.2 (A), LED63.2 (A), LED64.2 (A), U10.19 (SW4)
MTX_R5: LED65.2 (A), LED66.2 (A), LED67.2 (A), LED68.2 (A), LED69.2 (A), LED70.2 (A), LED71.2 (A), LED72.2 (A), LED73.2 (A), LED74.2 (A), LED75.2 (A), LED76.2 (A), LED77.2 (A), LED78.2 (A), LED79.2 (A), LED80.2 (A), U10.18 (SW5)
MTX_R6: LED81.2 (A), LED82.2 (A), LED83.2 (A), LED84.2 (A), LED85.2 (A), LED86.2 (A), LED87.2 (A), LED88.2 (A), LED89.2 (A), LED90.2 (A), LED91.2 (A), LED92.2 (A), LED93.2 (A), LED94.2 (A), LED95.2 (A), LED96.2 (A), U10.17 (SW6)
MTX_R7: LED97.2 (A), LED98.2 (A), LED99.2 (A), LED100.2 (A), LED101.2 (A), LED102.2 (A), LED103.2 (A), LED104.2 (A), LED105.2 (A), LED106.2 (A), LED107.2 (A), LED108.2 (A), LED109.2 (A), LED110.2 (A), LED111.2 (A), LED112.2 (A), U10.16 (SW7)
MTX_R8: LED113.2 (A), LED114.2 (A), LED115.2 (A), LED116.2 (A), LED117.2 (A), LED118.2 (A), LED119.2 (A), LED120.2 (A), LED121.2 (A), LED122.2 (A), LED123.2 (A), LED124.2 (A), LED125.2 (A), LED126.2 (A), LED127.2 (A), LED128.2 (A), U10.15 (SW8)
MTX_R9: LED129.2 (A), LED130.2 (A), LED131.2 (A), LED132.2 (A), LED133.2 (A), LED134.2 (A), LED135.2 (A), LED136.2 (A), LED137.2 (A), LED138.2 (A), LED139.2 (A), LED140.2 (A), LED141.2 (A), LED142.2 (A), LED143.2 (A), LED144.2 (A), U11.22 (SW1)
MTX_R10: LED145.2 (A), LED146.2 (A), LED147.2 (A), LED148.2 (A), LED149.2 (A), LED150.2 (A), LED151.2 (A), LED152.2 (A), LED153.2 (A), LED154.2 (A), LED155.2 (A), LED156.2 (A), LED157.2 (A), LED158.2 (A), LED159.2 (A), LED160.2 (A), U11.21 (SW2)
MTX_R11: LED161.2 (A), LED162.2 (A), LED163.2 (A), LED164.2 (A), LED165.2 (A), LED166.2 (A), LED167.2 (A), LED168.2 (A), LED169.2 (A), LED170.2 (A), LED171.2 (A), LED172.2 (A), LED173.2 (A), LED174.2 (A), LED175.2 (A), LED176.2 (A), U11.20 (SW3)
MTX_R12: LED177.2 (A), LED178.2 (A), LED179.2 (A), LED180.2 (A), LED181.2 (A), LED182.2 (A), LED183.2 (A), LED184.2 (A), LED185.2 (A), LED186.2 (A), LED187.2 (A), LED188.2 (A), LED189.2 (A), LED190.2 (A), LED191.2 (A), LED192.2 (A), U11.19 (SW4)
MTX_R13: LED193.2 (A), LED194.2 (A), LED195.2 (A), LED196.2 (A), LED197.2 (A), LED198.2 (A), LED199.2 (A), LED200.2 (A), LED201.2 (A), LED202.2 (A), LED203.2 (A), LED204.2 (A), LED205.2 (A), LED206.2 (A), LED207.2 (A), LED208.2 (A), U11.18 (SW5)
MTX_R14: LED209.2 (A), LED210.2 (A), LED211.2 (A), LED212.2 (A), LED213.2 (A), LED214.2 (A), LED215.2 (A), LED216.2 (A), LED217.2 (A), LED218.2 (A), LED219.2 (A), LED220.2 (A), LED221.2 (A), LED222.2 (A), LED223.2 (A), LED224.2 (A), U11.17 (SW6)
MTX_R15: LED225.2 (A), LED226.2 (A), LED227.2 (A), LED228.2 (A), LED229.2 (A), LED230.2 (A), LED231.2 (A), LED232.2 (A), LED233.2 (A), LED234.2 (A), LED235.2 (A), LED236.2 (A), LED237.2 (A), LED238.2 (A), LED239.2 (A), LED240.2 (A), U11.16 (SW7)
MTX_R16: LED241.2 (A), LED242.2 (A), LED243.2 (A), LED244.2 (A), LED245.2 (A), LED246.2 (A), LED247.2 (A), LED248.2 (A), LED249.2 (A), LED250.2 (A), LED251.2 (A), LED252.2 (A), LED253.2 (A), LED254.2 (A), LED255.2 (A), LED256.2 (A), U11.15 (SW8)
unnamed: C21.1, R7.2, Y1.3
unnamed: C22.1, R10.1, R14.2
unnamed: C23.2, R6.1
unnamed: C24.1, C25.1, R10.2
unnamed: C24.2, R9.1
unnamed: C33.1, J4.2, R26.2, R27.2
unnamed: C34.1, J5.2, R16.2, R25.2
unnamed: D2.2 (A), R32.1
unnamed: D3.2 (A), R31.1
unnamed: J2.2, R20.1
unnamed: J2.3, R21.1
unnamed: J2.4, R22.1
unnamed: J2.5, R23.1
unnamed: LS1.1 (LEAD+), U8.5 (VO+)
unnamed: LS1.2 (LEAD-), U8.8 (VO-)
unnamed: R8.1, SW7.1
unnamed: R43.2, SW8.2
unnamed: R48.1, U1.7 (GPIO4)
unnamed: R49.1, U1.8 (GPIO5)
unnamed: SW8.1, U1.26 (RUN)
unnamed: R3.2, U1.51 (USB_DM)
unnamed: R4.1, U1.52 (USB_DP)
unnamed: L1.1, U1.48 (VREG_LX)
unnamed: R24.2, U7.3 (~FLT)
unnamed: R9.2, U8.3 (IN+)
unnamed: R6.2, U8.4 (IN-)
unnamed: R17.1, U10.25 (ISET)
unnamed: R18.1, U11.25 (ISET)
QSPI_SCLK: U1.56 (QSPI_SCLK), U4.6 (CLK)
QSPI_SD0: U1.57 (QSPI_SD0), U4.5 (DI(IO0))
QSPI_SD1: U1.59 (QSPI_SD1), U4.2 (DO(IO1))
QSPI_SD2: U1.58 (QSPI_SD2), U4.3 (WP#(IO2))
QSPI_SD3: U1.55 (QSPI_SD3), U4.7 (HOLD#orRESET#(IO3))
QSPI_SS: R8.2, R19.2, U1.60 (~QSPI_SS), U4.1 (~CS)
SCL0: R12.1, R49.2, U10.27 (SCL), U11.27 (SCL), U11.28 (AD)
SDA0: R11.1, R48.2, U10.26 (SDA), U11.26 (SDA)
SWCLK: R20.2, U1.24 (SWCLK)
SWDIO: R21.2, U1.25 (SWDIO)
UART_RX: R22.2, U1.3 (GPIO1)
UART_TX: R23.2, U1.2 (GPIO0)
USB_CONN_D+: R4.2, U3.A6 (DP1), U3.B6 (DP2), U6.1
USB_CONN_D-: R3.1, U3.A7 (DN1), U3.B7 (DN2), U6.2
VBUS: C1.1, C2.1, R24.1, U2.2, U3.A4B9 (VBUS), U3.B4A9 (VBUS), U7.4 (EN), U7.5 (IN)
VREG_AVDD: C8.1, R5.2, U1.46 (VREG_AVDD)
XIN: C20.1, U1.21 (XIN), Y1.1
XOUT: R7.1, U1.22 (XOUT)

Notes on the sheet:
RP2350
Staus LED
アドレスの区別はAD
LEDドライバ
GPIO
2段ローパスフィルタ PWM搬送波除去
SWD, UART
ボタン
参考： https://nobulabo.com/amp-pam8302a/
Low=shutdown Highにしてから10usまってからI2C通信する
ISETで最大電流きまる
PWM音声出力
USB
LEDマトリクス
GROVE
アンプの拡大率による

Board: 4 copper layers, 90.0 x 130.0 mm, 362 parts (0 on the bottom side), 127 nets.

Other parts of the board:
BB1: Breadboard 47x35; Breadboard_47x35

File production/pv1/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C26, C3, C31, C32, C35, C36",0805,7,10uF,C1713
"C10, C11, C12, C13, C14, C15, C16, C18, C19, C2, C23, C24, C28, C29, C30, C37, C38, C9",0402,18,100nF,C1525
"C20, C21",0402,2,15pF,C1548
"C22, C25",0402,2,3.3nF,C3881585
"C27, C33, C34",0402,3,1uF,C52923
C4,0805,1,22uF,C45783
"C5, C6, C7, C8",0402,4,4.7uF,C23733
D2,0603,1,LED RED,C2286
D3,0805,1,LED GREEN,C2297
J1,PinSocket_2x10_P2.54mm_Vertical,1,BreadboardHdr_2x10,C2897411
"J4, J5",CONN-SMD_HY2.0-4P,2,HY2.0-4P-WT,C722729
L1,IND-SMD_L2.0-W1.6_AOTA-B201610S3R3-101-T,1,3.3uH,C42411119
"LED1, LED10, LED100, LED101, LED102, LED103, LED104, LED105, LED106, LED107, LED108, LED109, LED11, LED110, LED111, LED112, LED113, LED114, LED115, LED116, LED117, LED118, LED119, LED12, LED120, LED121, LED122, LED123, LED124, LED125, LED126, LED127, LED128, LED129, LED13, LED130, LED131, LED132, LED133, LED134, LED135, LED136, LED137, LED138, LED139, LED14, LED140, LED141, LED142, LED143, LED144, LED145, LED146, LED147, LED148, LED149, LED15, LED150, LED151, LED152, LED153, LED154, LED155, LED156, LED157, LED158, LED159, LED16, LED160, LED161, LED162, LED163, LED164, LED165, LED166, LED167, LED168, LED169, LED17, LED170, LED171, LED172, LED173, LED174, LED175, LED176, LED177, LED178, LED179, LED18, LED180, LED181, LED182, LED183, LED184, LED185, LED186, LED187, LED188, LED189, LED19, LED190, LED191, LED192, LED193, LED194, LED195, LED196, LED197, LED198, LED199, LED2, LED20, LED200, LED201, LED202, LED203, LED204, LED205, LED206, LED207, LED208, LED209, LED21, LED210, LED211, LED212, LED213, LED214, LED215, LED216, LED217, LED218, LED219, LED22, LED220, LED221, LED222, LED223, LED224, LED225, LED226, LED227, LED228, LED229, LED23, LED230, LED231, LED232, LED233, LED234, LED235, LED236, LED237, LED238, LED239, LED24, LED240, LED241, LED242, LED243, LED244, LED245, LED246, LED247, LED248, LED249, LED25, LED250, LED251, LED252, LED253, LED254, LED255, LED256, LED26, LED27, LED28, LED29, LED3, LED30, LED31, LED32, LED33, LED34, LED35, LED36, LED37, LED38, LED39, LED4, LED40, LED41, LED42, LED43, LED44, LED45, LED46, LED47, LED48",LED_0402_Compact_P1.6mm,200,LED_W,C20613596
"LED49, LED5, LED50, LED51, LED52, LED53, LED54, LED55, LED56, LED57, LED58, LED59, LED6, LED60, LED61, LED62, LED63, LED64, LED65, LED66, LED67, LED68, LED69, LED7, LED70, LED71, LED72, LED73, LED74, LED75, LED76, LED77, LED78, LED79, LED8, LED80, LED81, LED82, LED83, LED84, LED85, LED86, LED87, LED88, LED89, LED9, LED90, LED91, LED92, LED93, LED94, LED95, LED96, LED97, LED98, LED99",LED_0402_Compact_P1.6mm,56,LED_W,C20613596
LS1,BUZ-SMD_4P-L13.0-W13.0-P11.4-BL,1,SPK_8R_0.7W,C18186315
"R1, R2",0402,2,5.1k,C25905
"R10, R14, R43, R7, R8",0402,5,1k,C11702
"R11, R12",0402,2,2.2k,C25879
"R13, R15, R29, R30",0402,4,4.7k,C25900
"R17, R18",0402,2,33k,C25779
"R19, R24, R33, R34, R35, R36, R37, R38",0402,8,10k,C25744
"R20, R21, R22, R23",0402,4,22,C25092
"R25, R27, R28, R48, R49",0603,5,0,C21189
"R3, R4",0402,2,27,C25100
"R31, R32",0402,2,2k,C4109
R5,0402,1,33,C25105
"R6, R9",0402,2,47k,C25792
"SW1, SW2, SW3, SW4, SW5, SW6",KEY-SMD_4P-L6.0-W6.0-P4.50-LS8.6,6,SW_MEC_5G,C381038
SW7,SW-SMD_L3.9-W3.0-P4.45,1,BOOTSEL,C720477
SW8,SW-SMD_L3.9-W3.0-P4.45,1,RESET,C720477
U1,RP2350-QFN-60-1EP_7x7_P0.4mm_EP3.4x3.4mm_ThermalVias,1,RP2350A,C42411118
"U10, U11",QFN-32_L4.0-W4.0-P0.40-TL-EP2.8,2,IS31FL3729,C2940549
U2,SOD-323_L1.8-W1.3-LS2.7-BI,1,H5VHD3BC,C20615804
U3,USB-C-SMD_G-SWITCH_GT-USB-7010ASV,1,GT-USB-7010ASV,C2988369
U4,SOIC-8_L5.3-W5.3-P1.27-LS8.0-BL,1,W25Q64JVSSIQ,C179171
U6,SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR,1,PESD5V0U2BT,C2905622
U7,SOT-23-5,1,TPS2065CDBV,C353882
U8,MSOP-8_L3.0-W3.0-P0.65-LS5.0-BL,1,PAM8302AASCR,C113367
U9,SOT-223-3_L6.5-W3.4-P2.30-LS7.0-BR,1,AMS1117-3.3,C6186
Y1,CRYSTAL-SMD_4P-L3.2-W2.5-BL,1,12MHz,C20625731
